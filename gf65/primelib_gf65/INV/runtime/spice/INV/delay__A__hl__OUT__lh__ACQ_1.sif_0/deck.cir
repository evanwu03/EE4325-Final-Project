.title delay__A__hl__OUT__lh__ACQ_1

* state: 1
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx05a.utdallas.edu, User Name: ebw220000, PID: 3224703
* Directory: /var/tmp/primelib.engnx05a.771092.3224703/INV/delay__A__hl__OUT__lh__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/proj/cad/library/mosis/GF65_LPe/cmos10lpe_CDS_oa_dl064_11_20160415/models/YI-SM00030/Hspice/models/design.inc"

* **************************
* Temperature
* **************************

.temp 25

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option #"common,finesim: finesim_mode=spicehd finesim_method=gear finesim_speed=0 finesim_dvmax=0.1"

	"common,hspice: probe=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage"
.option measout=1 putmeas=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __param_vdd = 1.2
.param __param_vss = 0
.param ct = 3.6e-09
.param default_slew = 1.5e-11
.param energy_change_abs_threshold = 1e-12
.param energy_change_threshold = 0.05
.param initial_delay = 1e-11
.param load_out = 0
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param pp = 1.76e-09
.param slew_a = 5e-12
.param temperature_tag = 25
.param units = 3.6e-09
.param end_time = 5.3429e-09
.data arc_data
+ slew_a load_out temperature_tag __param_vdd __param_vss
+ 5e-12 0 25 1.2 0
+ 5e-12 3.2450834e-15 25 1.2 0
+ 5e-12 1.463604e-14 25 1.2 0
+ 5e-12 3.6388708e-14 25 1.2 0
+ 5e-12 7.0278299e-14 25 1.2 0
+ 5e-12 1.1782931e-13 25 1.2 0
+ 5e-12 1.804e-13 25 1.2 0
+ 1.0666304e-11 0 25 1.2 0
+ 1.0666304e-11 3.2450834e-15 25 1.2 0
+ 1.0666304e-11 1.463604e-14 25 1.2 0
+ 1.0666304e-11 3.6388708e-14 25 1.2 0
+ 1.0666304e-11 7.0278299e-14 25 1.2 0
+ 1.0666304e-11 1.1782931e-13 25 1.2 0
+ 1.0666304e-11 1.804e-13 25 1.2 0
+ 3.0556278e-11 0 25 1.2 0
+ 3.0556278e-11 3.2450834e-15 25 1.2 0
+ 3.0556278e-11 1.463604e-14 25 1.2 0
+ 3.0556278e-11 3.6388708e-14 25 1.2 0
+ 3.0556278e-11 7.0278299e-14 25 1.2 0
+ 3.0556278e-11 1.1782931e-13 25 1.2 0
+ 3.0556278e-11 1.804e-13 25 1.2 0
+ 6.8539041e-11 0 25 1.2 0
+ 6.8539041e-11 3.2450834e-15 25 1.2 0
+ 6.8539041e-11 1.463604e-14 25 1.2 0
+ 6.8539041e-11 3.6388708e-14 25 1.2 0
+ 6.8539041e-11 7.0278299e-14 25 1.2 0
+ 6.8539041e-11 1.1782931e-13 25 1.2 0
+ 6.8539041e-11 1.804e-13 25 1.2 0
+ 1.2771432e-10 0 25 1.2 0
+ 1.2771432e-10 3.2450834e-15 25 1.2 0
+ 1.2771432e-10 1.463604e-14 25 1.2 0
+ 1.2771432e-10 3.6388708e-14 25 1.2 0
+ 1.2771432e-10 7.0278299e-14 25 1.2 0
+ 1.2771432e-10 1.1782931e-13 25 1.2 0
+ 1.2771432e-10 1.804e-13 25 1.2 0
+ 2.1074409e-10 0 25 1.2 0
+ 2.1074409e-10 3.2450834e-15 25 1.2 0
+ 2.1074409e-10 1.463604e-14 25 1.2 0
+ 2.1074409e-10 3.6388708e-14 25 1.2 0
+ 2.1074409e-10 7.0278299e-14 25 1.2 0
+ 2.1074409e-10 1.1782931e-13 25 1.2 0
+ 2.1074409e-10 1.804e-13 25 1.2 0
+ 3.2e-10 0 25 1.2 0
+ 3.2e-10 3.2450834e-15 25 1.2 0
+ 3.2e-10 1.463604e-14 25 1.2 0
+ 3.2e-10 3.6388708e-14 25 1.2 0
+ 3.2e-10 7.0278299e-14 25 1.2 0
+ 3.2e-10 1.1782931e-13 25 1.2 0
+ 3.2e-10 1.804e-13 25 1.2 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/010/e/eb/ebw220000/cad/EE4325_UART_Project/gf65/primelib_gf65/INV/netlists/INV.pex.sp'
xinv_inst vss out vdd in INV
vin_meter in in_harness dc 0
vout_meter out out_harness dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_out out_harness ground_out 'load_out'
ccap_vdd vdd_harness ground_vdd 4e-14
ccap_vss vss_harness ground_vss 4e-14
vcap_ground_out ground_out 0 dc 0
vcap_ground_vdd ground_vdd 0 dc 0
vcap_ground_vss ground_vss 0 dc 0
va_stim a 0 pwl
+  0  1.2
+  1e-11  1.2
+  '1e-11 + slew_a * 1.25'  0
+  1.77e-09  0
* **************************
* Measurements
* **************************

.meas tran cin__a__hl_trig when v(a)=1.14 cross=1 td=1e-11
.meas tran cin__a__hl_targ when v(a)=0.06 cross=1 td=1e-11
