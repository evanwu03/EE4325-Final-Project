.title leakage_power__ACQ_1

* state: !INA&OUT
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx05a.utdallas.edu, User Name: ebw220000, PID: 1482083
* Directory: /var/tmp/primelib.engnx05a.771092.1482083/INV/leakage_power__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/home/eng/v/vks160030/Desktop/ASAP7_PDKandLIB_v1p5/asap7PDK_r1p5/models/hspice/7nm_TT.pm"

* **************************
* Temperature
* **************************

.temp 25

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option #"common,finesim: finesim_mode=spicehd finesim_method=gear finesim_speed=0 finesim_dvmax=0.1"

	"common,hspice: probe=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage"
.option measout=1 putmeas=0
.option post=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __dummy__ = 0
.param __param_ina = 0
.param __param_vdd = 1.2
.param __param_vss = 0
.param ct = 3.6e-09
.param default_slew = 1.5e-11
.param gate_leakage_multiplication_factor = 1
.param initial_delay = 1e-09
.param load_out = 4e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param pp = 1.76e-09
.param temperature_tag = 25
.param trailing_delay = 3.52e-09
.param units = 3.6e-09
.param end_time = 8.120399999999999e-09
.data arc_data
+ __dummy__ temperature_tag __param_vdd __param_vss
+ 0 25 1.2 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/010/e/eb/ebw220000/cad/EE4325_UART_Project/gf65/primelib_gf65/INV/netlists/inv.pex.sp'
xinv_inst vss out vdd ina INV
vina_meter ina ina_harness dc 0
vina_stim ina_harness 0 dc 0
vout_meter out out_harness dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_out out_harness vss 4e-14
ccap_vdd vdd_harness vss 4e-14
ccap_vss vss_harness vss 4e-14
* **************************
* Measurements
* **************************

.meas tran input_current_ina avg i(vina_stim) from=2.76e-09 to=4.52e-09
.meas tran input_voltage_ina avg v(ina_harness) from=2.76e-09 to=4.52e-09
.meas tran supply_current_vdd avg i(vvdd_stim) from=2.76e-09 to=4.52e-09
.meas tran supply_current_vss avg i(vvss_stim) from=2.76e-09 to=4.52e-09
.meas tran supply_voltage_vdd avg v(vdd_harness) from=2.76e-09 to=4.52e-09
.meas tran supply_voltage_vss avg v(vss_harness) from=2.76e-09 to=4.52e-09
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-12 8.120399999999999e-09 sweep data=arc_data

.end
