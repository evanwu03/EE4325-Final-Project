.title Cin__VDD__hl__ACQ_1

* state: !INA&!OUT&!VSS
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx05a.utdallas.edu, User Name: ebw220000, PID: 1482083
* Directory: /var/tmp/primelib.engnx05a.771092.1482083/INV/Cin__VDD__hl__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/home/eng/v/vks160030/Desktop/ASAP7_PDKandLIB_v1p5/asap7PDK_r1p5/models/hspice/7nm_TT.pm"

* **************************
* Temperature
* **************************

.temp 25

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option #"common,finesim: finesim_mode=spicehd finesim_method=gear finesim_speed=0 finesim_dvmax=0.1"

	"common,hspice: probe=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage"
.option measout=1 putmeas=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __param_ina = 0
.param __param_vdd = 1.2
.param __param_vss = 0
.param ct = 3.6e-09
.param default_slew = 1.5e-11
.param initial_delay = 1e-11
.param load_out = 4e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param pp = 1.76e-09
.param slew_vdd = 5e-12
.param temperature_tag = 25
.param units = 3.6e-09
.data arc_data
+ slew_vdd temperature_tag __param_vdd __param_vss
+ 5e-12 25 1.2 0
+ 1.0666304e-11 25 1.2 0
+ 3.0556278e-11 25 1.2 0
+ 6.8539041e-11 25 1.2 0
+ 1.2771432e-10 25 1.2 0
+ 2.1074409e-10 25 1.2 0
+ 3.2e-10 25 1.2 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/010/e/eb/ebw220000/cad/EE4325_UART_Project/gf65/primelib_gf65/INV/netlists/inv.pex.sp'
xinv_inst vss out vdd ina INV
vina_meter ina ina_harness dc 0
vina_stim ina_harness 0 dc 0
vout_meter out out_harness dc 0
vvdd_meter vdd vdd_harness dc 0
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
ccap_out out_harness vss 4e-14
ccap_vss vss_harness vss 4e-14
vvdd_stim vdd_harness 0 pwl
+  0  1.2
+  1e-11  1.2
+  '1e-11 + slew_vdd * 1.25'  0
+  1.77e-09  0
* **************************
* Measurements
* **************************

.meas tran cin__vdd__hl_trig when v(vdd)=1.14 cross=1 td=1e-11
.meas tran cin__vdd__hl_targ when v(vdd)=0.06 cross=1 td=1e-11
.meas tran cin__vdd__hl_q integ i(vvdd_meter) from='cin__vdd__hl_trig' to='cin__vdd__hl_targ'
* Return abs((Cin__VDD__hl_q)/(-1.08))
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-12 5.3429e-09 sweep data=arc_data

.end
