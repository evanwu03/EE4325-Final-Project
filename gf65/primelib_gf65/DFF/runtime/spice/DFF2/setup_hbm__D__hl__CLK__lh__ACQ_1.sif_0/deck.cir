.title setup_hbm__D__hl__CLK__lh__ACQ_1

* state: !R
* state_coverage: 1

* Deck file generated by PrimeLib T-2022.03-SP1 build date: Apr 12, 2022 13:01:04. (SMSC-2)
* PrimeLib path: /proj/cad/synopsys/synopsys_2021/primelib/T-2022.03-SP1/linux64/bin/primelib
* Host Name: engnx05a.utdallas.edu, User Name: ebw220000, PID: 2722789
* Directory: /var/tmp/primelib.engnx05a.771092.2722789/DFF2/setup_hbm__D__hl__CLK__lh__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.include "/proj/cad/library/mosis/GF65_LPe/cmos10lpe_CDS_oa_dl064_11_20160415/models/YI-SM00030/Hspice/models/design.inc"

* **************************
* Temperature
* **************************

.temp 25

* **************************
* Model
* **************************

.model optmod opt METHOD = PASSFAIL ABSIN = 1e-11 ITROPT = 50

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option altcc=1 dynacc=1
.option mcbrief=5
.option #"common,finesim: finesim_mode=spicehd finesim_method=gear finesim_speed=0 finesim_dvmax=0.1"

	"common,hspice: probe=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage"
.option measout=1 putmeas=0
.option bisec_pushout_init=1 dynacc=0
.option extend_bisec_window=20

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __param_r = 0
.param ct = 3.6e-09
.param default_slew = 1.5e-11
.param degrade_setup = 0
.param driver_delay_clk = 3.125e-12
.param driver_delay_d = 3.125e-12
.param initial_delay = 1e-11
.param load_q = 4e-14
.param load_vdd = 4e-14
.param load_vss = 4e-14
.param max_setup = -4.8e-10
.param min_setup = 4.8e-10
.param opt_tolerance = 1e-11
.param setup = -4.8e-10
.param stable = 2e-09
.param units = 3.6e-09
* **************************
* HBM OPT PARAM
* **************************

.param setup = opt1('min_setup','init_hbm','init_hbm-1.99e-11-0.15*sis_exp_factor')

.param sis_exp_factor = '(0.3/0.3)*(slew_D+slew_CLK)'
.param sis_skip_first_iteration = '1'
.param M_constraint_CLK = '(setup>0)'
.param M_constraint = '(setup<0)'
* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/home/010/e/eb/ebw220000/cad/EE4325_UART_Project/gf65/primelib_gf65/DFF2/netlists/dff2.pex.sp'
.ic
.inc '/home/010/e/eb/ebw220000/cad/EE4325_UART_Project/gf65/primelib_gf65/DFF2/results/DFF2/initialization__ACQ_5.op_cond.initialization'
xdff2_inst vss vdd clk r d q DFF2
vclk_meter clk clk_harness dc 0
vd_meter d d_harness dc 0
vq_meter q q_harness dc 0
vr_meter r r_harness dc 0
vr_stim r_harness 0 dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 1.2
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_q q_harness vss 4e-14
ccap_vdd vdd_harness vss 4e-14
ccap_vss vss_harness vss 4e-14
vclk_stim clk_harness 0 pwl
+  0  0
+  '1e-11 + m_constraint_clk * setup'  0
+  '1e-11 + m_constraint_clk * setup + slew_clk * 1.25'  1.2
+  '1e-11 + m_constraint_clk * setup + 2e-09'  1.2
vd_stim d_harness 0 pwl
+  0  1.2
+  '1e-11 - m_constraint * setup'  1.2
+  '1e-11 + slew_d * 1.25 - m_constraint * setup'  0
+  '1e-11 - m_constraint * setup + 2e-09'  0
* **************************
* Measurements
* **************************

.meas tran tin__clk__lh_trig when v(clk)=0.12 rise=1 td='1e-11 + m_constraint_clk * setup'
.meas tran tin__clk__lh_targ when v(clk)=1.08 rise=1 td='1e-11 + m_constraint_clk * setup'
* Return ((Tin__CLK__lh_targ)-(Tin__CLK__lh_trig))*(1)
.meas tran tin__d__hl_trig when v(d)=1.08 fall=1 td='1e-11 - m_constraint * setup'
.meas tran tin__d__hl_targ when v(d)=0.12 fall=1 td='1e-11 - m_constraint * setup'
* Return ((Tin__D__hl_targ)-(Tin__D__hl_trig))*(1)
.meas tran tout_hbm__q__hl_trig when v(q)=1.08 fall=1 td='1e-11 - m_constraint * setup'
.meas tran tout_hbm__q__hl_targ when v(q)=0.12 fall=1 td='1e-11 - m_constraint * setup'
.meas tran tout_hbm__q__hl_value PARAM = 'Tout_hbm__Q__hl_targ-Tout_hbm__Q__hl_trig'
* Return Tout_hbm__Q__hl_value
.meas tran fallback_hbm__q__hl_trig when v(q)=0.12 cross=last  td='1e-11 - m_constraint * setup'
.meas tran fallback_hbm__q__hl_targ when v(q)=1.08 cross=last  td='1e-11 - m_constraint * setup'
.meas tran fallback_hbm__q__hl_value PARAM = 'fallback_hbm__Q__hl_targ-fallback_hbm__Q__hl_trig'
* Return fallback_hbm__Q__hl_value
.meas tran setup_applied param='setup'
.meas tran setup_hbm__d__hl__clk__lh_trig when v(d)=0.6 fall=1 td='1e-11 - m_constraint * setup'
.meas tran setup_hbm__d__hl__clk__lh_targ when v(clk)=0.6 rise=1 td='1e-11 + m_constraint_clk * setup'
.meas tran setup_hbm__d__hl__clk__lh_value PARAM = 'setup_hbm__D__hl__CLK__lh_targ-setup_hbm__D__hl__CLK__lh_trig'
* Return setup_hbm__D__hl__CLK__lh_value
.meas tran sis_fallback1 PARAM = 'min((fallback_hbm__Q__hl_trig-tout_hbm__Q__hl_targ),(fallback_hbm__Q__hl_targ-tout_hbm__Q__hl_trig))'
.meas tran sis_fallback1_check PARAM = 'sis_fallback1==0'
.meas tran sis_fallback1_opt FIND PAR('1') AT ='sis_fallback1_check? 0 : -1'
.meas tran sis_passlist PARAM = 'min(setup_hbm__D__hl__CLK__lh_trig, min(setup_hbm__D__hl__CLK__lh_targ, min(tin__D__hl_trig, min(tin__D__hl_targ, min(tin__CLK__lh_trig, min(tin__CLK__lh_targ, min(tout_hbm__Q__hl_trig, tout_hbm__Q__hl_targ)))))))'
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-12 6.0701e-09 sweep OPTIMIZE = opt1 RESULT = sis_passlist,sis_fallback1_opt MODEL = optmod data=arc_data

.data arc_data
+ slew_d slew_clk temperature_tag __param_vdd __param_vss init_hbm
+ 5e-12 5e-12 25 1.2 0 0
+ 5e-12 1.0666304e-11 25 1.2 0 -3.54144e-12
+ 5e-12 3.0556278e-11 25 1.2 0 -1.597267375e-11
+ 5e-12 6.8539041e-11 25 1.2 0 -3.971190062499999e-11
+ 5e-12 1.2771432e-10 25 1.2 0 -7.669645e-11
+ 5e-12 2.1074409e-10 25 1.2 0 -1.2859005625e-10
+ 5e-12 3.2e-10 25 1.2 0 -1.96875e-10
+ 1.0666304e-11 5e-12 25 1.2 0 3.54144e-12
+ 1.0666304e-11 1.0666304e-11 25 1.2 0 0
+ 1.0666304e-11 3.0556278e-11 25 1.2 0 -1.243123375e-11
+ 1.0666304e-11 6.8539041e-11 25 1.2 0 -3.617046062499999e-11
+ 1.0666304e-11 1.2771432e-10 25 1.2 0 -7.315501e-11
+ 1.0666304e-11 2.1074409e-10 25 1.2 0 -1.2504861625e-10
+ 1.0666304e-11 3.2e-10 25 1.2 0 -1.9333356e-10
+ 3.0556278e-11 5e-12 25 1.2 0 1.597267375e-11
+ 3.0556278e-11 1.0666304e-11 25 1.2 0 1.243123375e-11
+ 3.0556278e-11 3.0556278e-11 25 1.2 0 0
+ 3.0556278e-11 6.8539041e-11 25 1.2 0 -2.3739226875e-11
+ 3.0556278e-11 1.2771432e-10 25 1.2 0 -6.072377625000001e-11
+ 3.0556278e-11 2.1074409e-10 25 1.2 0 -1.126173825e-10
+ 3.0556278e-11 3.2e-10 25 1.2 0 -1.8090232625e-10
+ 6.8539041e-11 5e-12 25 1.2 0 3.971190062499999e-11
+ 6.8539041e-11 1.0666304e-11 25 1.2 0 3.617046062499999e-11
+ 6.8539041e-11 3.0556278e-11 25 1.2 0 2.3739226875e-11
+ 6.8539041e-11 6.8539041e-11 25 1.2 0 0
+ 6.8539041e-11 1.2771432e-10 25 1.2 0 -3.6984549375e-11
+ 6.8539041e-11 2.1074409e-10 25 1.2 0 -8.8878155625e-11
+ 6.8539041e-11 3.2e-10 25 1.2 0 -1.57163099375e-10
+ 1.2771432e-10 5e-12 25 1.2 0 7.669645e-11
+ 1.2771432e-10 1.0666304e-11 25 1.2 0 7.315501e-11
+ 1.2771432e-10 3.0556278e-11 25 1.2 0 6.072377625000001e-11
+ 1.2771432e-10 6.8539041e-11 25 1.2 0 3.6984549375e-11
+ 1.2771432e-10 1.2771432e-10 25 1.2 0 0
+ 1.2771432e-10 2.1074409e-10 25 1.2 0 -5.189360624999999e-11
+ 1.2771432e-10 3.2e-10 25 1.2 0 -1.2017855e-10
+ 2.1074409e-10 5e-12 25 1.2 0 1.2859005625e-10
+ 2.1074409e-10 1.0666304e-11 25 1.2 0 1.2504861625e-10
+ 2.1074409e-10 3.0556278e-11 25 1.2 0 1.126173825e-10
+ 2.1074409e-10 6.8539041e-11 25 1.2 0 8.8878155625e-11
+ 2.1074409e-10 1.2771432e-10 25 1.2 0 5.189360624999999e-11
+ 2.1074409e-10 2.1074409e-10 25 1.2 0 0
+ 2.1074409e-10 3.2e-10 25 1.2 0 -6.828494374999999e-11
+ 3.2e-10 5e-12 25 1.2 0 1.96875e-10
+ 3.2e-10 1.0666304e-11 25 1.2 0 1.9333356e-10
+ 3.2e-10 3.0556278e-11 25 1.2 0 1.8090232625e-10
+ 3.2e-10 6.8539041e-11 25 1.2 0 1.57163099375e-10
+ 3.2e-10 1.2771432e-10 25 1.2 0 1.2017855e-10
+ 3.2e-10 2.1074409e-10 25 1.2 0 6.828494374999999e-11
+ 3.2e-10 3.2e-10 25 1.2 0 0
.enddata

.end
